Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2024-01-02T18:36:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jan 02 18:36:51 2024 * Host: ZIL2DTCLS3 * Database: C:\Users\cdprasad\AppData\Local\Temp\b40a5899-713d-4e44-8f39-d71f96d326e5\517a55cd-fa29-4709-8ef0-7395e047e2bd\ifc * Database version: 5507 * Database creation date: Tue Jan 02 18:36:51 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jan 02 18:36:51 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jan 02 18:36:51 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: NSFB254-J:NSFB254-J, NSFB254-J:NSFB254-J:763199
In: Level 1
Type - Material: Metal - Steel - Stainless - Chrome
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - Bowl 1 Dimensions: 27 inch x 24 inch x 14 inch; Bowl 2 Dimensions: 27 inch x 24 inch x 14 inch; Drain Location: Center; Drain Size: 3 1/2 inch; Finish: Satin; Gauge: 14; Material: 304 Stainless Steel; Number of Bowls: 2; Sink Dimensions: 57 inch x 27 1/2 inch x 44 inch
Type - Identity Data - Description: Just Mfg Stainless Steel_57 inch x 27 1/2 inch x 14 inch; Manufacturer: www.justmfg.com; OmniClass Number: 23.45.05.14.14.27; OmniClass Title: Service Sinks; Type Name: NSFB254-J; URL: www.justmfg.com
Type - Other - Category: Plumbing Fixtures; Family Name: NSFB254-J
Type - Pset_ManufacturerTypeInformation - Manufacturer: www.justmfg.com
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: NSFB254-J
Pset_DistributionFlowElementCommon - Reference: NSFB254-J; sets with these values: 2
Constraints - Elevation from Level: 0 mm; Level: Level: Level 1; Offset from Host: 0 mm; Schedule Level: Level: Level 1; Work Plane: Level : Level 1
Dimensions - Area: 3.15405 m2; Volume: 0.00921862 m3
Identity Data - Mark: 1
Other - Family: NSFB254-J: NSFB254-J; Family and Type: NSFB254-J: NSFB254-J; Type: NSFB254-J: NSFB254-J; Type Id: NSFB254-J: NSFB254-J
Phasing - Phase Created: New Construction
